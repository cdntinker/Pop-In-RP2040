File: test.kicad_pcb (KiCad board)
At the start: 2 copper layers, 30.5 x 35.6 mm, 1 part

Commit message: ...
Other:
- board size 30.5 x 35.6 mm -> 30.5 x 33 mm
